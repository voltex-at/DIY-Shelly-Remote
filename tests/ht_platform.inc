/* Genuine HTTP/parser/registry/fleet; transport, SDK, Flash and time MODEL. */
static const char ht_identity[]="{\"gen\":3,\"id\":\"shellyhtg3-AABBCCDDEEFF\",\"model\":\"S3SN-0U12A\"}";
static const char ht_zero[]="{\"temperature:0\":{\"id\":0,\"tC\":0,\"tF\":32},\"humidity:0\":{\"id\":0,\"rh\":0},\"devicepower:0\":{\"id\":0,\"battery\":{\"percent\":0,\"V\":0},\"external\":{\"present\":false}}}";
static dsr_connection_t ht_connection(void)
{dsr_connection_t c=connection();c.device.generation=DSR_GEN2_PLUS;c.device.endpoint_kind=DSR_ENDPOINT_HT;strcpy(c.device.device_id,"shellyhtg3-AABBCCDDEEFF");return c;}
static void test_ht_protocol(void)
{
 dsr_connection_t c=ht_connection();dsr_device_t d;dsr_telemetry_t t;step_t data[]={{"/shelly",ht_identity,200,false,false},{"/rpc/Shelly.GetStatus",ht_zero,200,false,true}};
 fixture(data,2,HTTP_AUTH_TYPE_DIGEST);CHECK(dsr_http_probe_telemetry(&c,&d,&t)==DSR_OK&&used==2&&d.online&&!d.has_switch&&!d.has_power&&!d.output&&d.power_w==0&&t.has_temperature&&t.has_humidity&&t.has_battery&&t.temperature_c==0&&t.humidity_pct==0&&t.battery_pct==0&&t.ht.flags==(DSR_HT_VALID|DSR_HT_EXTERNAL_KNOWN));
 fixture(data,0,HTTP_AUTH_TYPE_DIGEST);CHECK(dsr_http_set_output(&c,true)==DSR_UNSUPPORTED&&used==0);
 dsr_connection_t wrong=c;wrong.device.endpoint_kind=DSR_ENDPOINT_SWITCH;fixture(data,1,HTTP_AUTH_TYPE_DIGEST);CHECK(dsr_http_probe_telemetry(&wrong,&d,&t)==DSR_UNSUPPORTED&&used==1);
 const char *bad_identity[]={"{\"gen\":2,\"id\":\"shellyhtg3-AABBCCDDEEFF\",\"model\":\"S3SN-0U12A\"}","{\"gen\":3,\"id\":\"shellyhtg3-AABBCCDDEEFF\",\"model\":\"other\"}","{\"gen\":3,\"id\":\"foreign\",\"model\":\"S3SN-0U12A\"}"};
 for(unsigned i=0;i<3;i++){data[0].body=bad_identity[i];fixture(data,1,HTTP_AUTH_TYPE_DIGEST);CHECK(dsr_http_probe_telemetry(&c,&d,&t)!=DSR_OK&&used==1&&!d.online);}data[0].body=ht_identity;
 cJSON *root=cJSON_Parse(ht_zero);dsr_lan_capabilities_t caps;CHECK(dsr_lan_parse_capabilities(root,3,&caps)==DSR_OK&&caps.ht&&!caps.switches&&!caps.covers&&!caps.lights&&!caps.rgbs);CHECK(dsr_lan_parse_capabilities(root,2,&caps)==DSR_OK&&!caps.ht);
 cJSON *temperature=cJSON_GetObjectItemCaseSensitive(root,"temperature:0"),*humidity=cJSON_GetObjectItemCaseSensitive(root,"humidity:0"),*power=cJSON_GetObjectItemCaseSensitive(root,"devicepower:0"),*battery=cJSON_GetObjectItemCaseSensitive(power,"battery");
 cJSON_SetNumberValue(cJSON_GetObjectItemCaseSensitive(temperature,"tC"),-12.25);cJSON_SetNumberValue(cJSON_GetObjectItemCaseSensitive(humidity,"rh"),99.25);cJSON_SetNumberValue(cJSON_GetObjectItemCaseSensitive(battery,"percent"),.5);CHECK(dsr_ht_parse(root,&t)==DSR_OK&&t.has_temperature&&t.temperature_c==-12.25&&t.has_humidity&&t.humidity_pct==99.25&&t.has_battery&&t.battery_pct==.5);
 cJSON_ReplaceItemInObjectCaseSensitive(temperature,"tC",cJSON_CreateNull());CHECK(dsr_ht_parse(root,&t)==DSR_OK&&!t.has_temperature&&t.has_humidity&&t.has_battery&&!t.ht.errors);
 cJSON_ReplaceItemInObjectCaseSensitive(humidity,"rh",cJSON_CreateNull());cJSON_ReplaceItemInObjectCaseSensitive(battery,"percent",cJSON_CreateNull());CHECK(dsr_ht_parse(root,&t)==DSR_OK&&!t.has_temperature&&!t.has_humidity&&!t.has_battery&&!t.ht.errors);
 cJSON_ReplaceItemInObjectCaseSensitive(temperature,"tC",cJSON_CreateNumber(-273.15));cJSON_ReplaceItemInObjectCaseSensitive(humidity,"rh",cJSON_CreateNumber(100));cJSON_ReplaceItemInObjectCaseSensitive(battery,"percent",cJSON_CreateNumber(100));CHECK(dsr_ht_parse(root,&t)==DSR_OK&&t.has_temperature&&t.has_humidity&&t.has_battery);
 cJSON_ReplaceItemInObjectCaseSensitive(battery,"V",cJSON_CreateString("bad optional voltage"));CHECK(dsr_ht_parse(root,&t)==DSR_OK&&t.has_temperature&&t.has_humidity&&!t.has_battery&&t.ht.errors==DSR_HT_POWER_ERROR&&!(t.ht.flags&DSR_HT_EXTERNAL_KNOWN));
 cJSON_AddItemToObject(temperature,"errors",cJSON_Parse("[\"read\"]"));CHECK(dsr_ht_parse(root,&t)==DSR_OK&&!t.has_temperature&&t.has_humidity&&t.ht.errors==(DSR_HT_TEMPERATURE_ERROR|DSR_HT_POWER_ERROR));cJSON_Delete(root);
 const char *bad[]={"null","{}","{\"temperature:0\":{\"id\":0},\"humidity:0\":{\"id\":0},\"devicepower:0\":{\"id\":1}}","{\"temperature:0\":{\"id\":0,\"tC\":0,\"tC\":20},\"humidity:0\":{\"id\":0},\"devicepower:0\":{\"id\":0}}"};
 for(unsigned i=0;i<4;i++){data[1].body=bad[i];fixture(data,2,HTTP_AUTH_TYPE_DIGEST);CHECK(dsr_http_probe_telemetry(&c,&d,&t)!=DSR_OK&&!d.online&&used==2);}
 for(unsigned field=0;field<3;field++)for(unsigned bad_number=0;bad_number<3;bad_number++){root=cJSON_Parse(ht_zero);const char *section[]={"temperature:0","humidity:0","devicepower:0"};cJSON *obj=cJSON_GetObjectItemCaseSensitive(root,section[field]);if(field==2)obj=cJSON_GetObjectItemCaseSensitive(obj,"battery");const char *key=field==0?"tC":field==1?"rh":"percent";cJSON_ReplaceItemInObjectCaseSensitive(obj,key,bad_number==0?cJSON_CreateString("0"):bad_number==1?cJSON_CreateNumber(field?100.01:1000.01):cJSON_CreateNumber(field?-.01:-273.16));CHECK(dsr_ht_parse(root,&t)==DSR_OK&&t.ht.errors==(1u<<field));cJSON_Delete(root);}
 admission_open();
}
static void test_ht_registry_fleet(void)
{
 memset(sizes,0,sizeof(sizes));memset(schemas,0,sizeof(schemas));dsr_connection_t c=ht_connection();c.layout_id=78;CHECK(dsr_connection_save(&c)==ESP_OK&&sizes[2]==4104&&((uint32_t*)blobs[2])[0]==6);unsigned writes=write_opens;dsr_connection_t loaded[16];size_t n;
 CHECK(dsr_connections_load(loaded,16,&n)==ESP_OK&&n==1&&loaded[0].device.endpoint_kind==DSR_ENDPOINT_HT&&!loaded[0].device.online&&writes==write_opens);
 for(unsigned version=3;version<=7;version++)if(version!=6){((uint32_t*)blobs[2])[0]=version;CHECK(dsr_connections_load(loaded,16,&n)!=ESP_OK&&!n&&dsr_connection_save(&c)!=ESP_OK&&writes==write_opens);}
 ((uint32_t*)blobs[2])[0]=6;
 c.layout_id=0;CHECK(dsr_connection_remove(&c)==ESP_OK&&dsr_connection_save(&c)==ESP_OK);CHECK(dsr_connections_load(loaded,16,&n)==ESP_OK&&n==1&&!loaded[0].legacy_fallback);dsr_fleet_t f={0};CHECK(dsr_fleet_upsert(&f,&loaded[0],10)==DSR_OK&&dsr_fleet_ht_refresh(&f,0,true,10)==DSR_IDENTITY_MISMATCH);
 c.layout_id=78;c.device.online=true;c.telemetry=(dsr_telemetry_t){.has_temperature=true,.temperature_c=-12.5,.has_humidity=true,.humidity_pct=0,.ht={.flags=DSR_HT_VALID}};CHECK(dsr_fleet_upsert(&f,&c,100)==DSR_OK&&f.slots[0].next_poll==60100);CHECK(dsr_fleet_request(&f,0,true,true,100)==DSR_UNSUPPORTED);
 const dsr_result_t errors[]={DSR_OFFLINE,DSR_BAD_RESPONSE,DSR_UNSUPPORTED,DSR_RATE_LIMITED,DSR_IO};
 for(unsigned i=0;i<5;i++){CHECK(dsr_fleet_ht_refresh(&f,0,true,200+i)==DSR_OK&&dsr_fleet_ht_refresh(&f,0,true,200+i)==DSR_BUSY);dsr_job_t job;unsigned at;CHECK(dsr_fleet_next(&f,200+i,false,&job,&at)&&job.kind==DSR_JOB_PROBE);job.id=500+i;dsr_fleet_started(&f,at,&job);dsr_event_t event={.id=job.id,.device=c.device,.result=errors[i]};CHECK(dsr_fleet_complete(&f,at,&event,300+i)&&f.slots[0].sample_ms==100&&f.slots[0].sample_valid&&f.slots[0].connection.telemetry.temperature_c==-12.5&&!f.slots[0].connection.device.online&&f.slots[0].next_poll-(300+i)<=900000);admission_open();}
 CHECK(dsr_fleet_ht_refresh(&f,0,false,400)==DSR_OFFLINE);CHECK(dsr_fleet_ht_refresh(&f,0,true,400)==DSR_OK);dsr_job_t job;unsigned at;CHECK(dsr_fleet_next(&f,400,false,&job,&at));job.id=600;dsr_fleet_started(&f,at,&job);dsr_event_t event={.id=600,.device=c.device,.result=DSR_OK,.telemetry={.ht={.flags=DSR_HT_VALID}}};event.device.online=true;CHECK(dsr_fleet_complete(&f,at,&event,500)&&f.slots[0].sample_ms==500&&!f.slots[0].connection.telemetry.has_temperature&&!f.slots[0].connection.telemetry.has_humidity);admission_open();
 CHECK(dsr_fleet_ht_refresh(&f,0,true,501)==DSR_OK);f.slots[0].layout_enabled=false;CHECK(!dsr_fleet_next(&f,501,false,&job,&at)&&!f.slots[0].queued);admission_open();f.slots[0].layout_enabled=true;CHECK(dsr_fleet_ht_refresh(&f,0,true,502)==DSR_OK);strcpy(f.slots[0].connection.device.host,"192.168.1.99");CHECK(!dsr_fleet_next(&f,502,false,&job,&at)&&!f.slots[0].queued);admission_open();
 c.device.channel=1;CHECK(!dsr_connection_valid(&c,true));CHECK(sizeof(dsr_telemetry_t)==32&&sizeof(dsr_connection_t)==296&&sizeof(dsr_fleet_t)==8080&&sizeof(dsr_job_t)==560&&sizeof(dsr_event_t)==1192);
}
